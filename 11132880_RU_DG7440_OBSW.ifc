Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2021-06-29T16:41:46
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.0.1169.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jun 29 16:41:46 2021 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\{E5CA05BE-1F75-4DEC-831D-3415F61CD96C}\ifc * Database version: 5507 * Database creation date: Tue Jun 29 16:41:45 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jun 29 16:41:45 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jun 29 16:41:45 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 23744020_RU_11132880_DG7440_OBSW, 11132880_RU_DG7440_OBSW:23744020_RU_11132880_DG7440_OBSW:205682
In: Level 1
Type - Material: z_Miele_Design_Zinc_Steel, z_Miele_Connection_Electric, z_Miele_Design_Steel_Chrom, z_Miele_Design_OBSW
Pset_BuildingElementProxyCommon - Reference: 23744020_RU_11132880_DG7440_OBSW
Pset_ManufacturerTypeInformation - Manufacturer: Miele
